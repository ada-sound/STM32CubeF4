# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F413xx,USE_STM32F413H_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers/CMSIS/Include;../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F413H-Discovery;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_i2s.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_sai.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sram.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_dac.c stm32f4xx_hal_flash.c stm32f4xx_hal_pcd.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_hash.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_hcd.c stm32f4xx_hal.c stm32f4xx_ll_usb.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cec.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_nor.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_sd.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_can.c stm32f4xx_hal_sdram.c stm32f4xx_hal_adc.c stm32f4xx_hal_dsi.c stm32f4xx_hal_pccard.c stm32f4xx_hal_irda.c
  group Drivers/BSP/STM32F413H_DISCOVERY
    ../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery_ts.c stm32f413h_discovery_qspi.c stm32f413h_discovery_psram.c stm32f413h_discovery.c stm32f413h_discovery_lcd.c stm32f413h_discovery_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/MDK-ARM
    ./: startup_stm32f413xx.s
  group Example/User
    ../Src/: stm32f4xx_it.c main.c
software components: CMSIS:CORE 4.3.0
