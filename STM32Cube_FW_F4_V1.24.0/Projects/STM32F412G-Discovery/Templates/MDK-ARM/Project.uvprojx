# Keil uVision project Project.uvprojx, settings and files
target STM32412G_DISCOVERY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32412G_DISCOVERY
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F412Zx,USE_STM32412G_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers/CMSIS/Include;../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32412G-Discovery;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32412G_DISCOVERY
    ../../../../Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery.c stm32412g_discovery_qspi.c stm32412g_discovery_audio.c stm32412g_discovery_sd.c stm32412g_discovery_eeprom.c
  group Example/User
    ../Src/: main.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_hcd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_sdram.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_cryp.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_rcc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_nor.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rng.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cec.c stm32f4xx_hal_flash.c stm32f4xx_hal_irda.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_usart.c stm32f4xx_hal.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dsi.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_adc.c stm32f4xx_hal_sai.c stm32f4xx_hal_pccard.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_usb.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_flash_ramfunc.c
  group Example/MDK-ARM
    ./: startup_stm32f412zx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
software components: CMSIS:CORE 4.3.0
